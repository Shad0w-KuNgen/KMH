## kernel/Kconfig
```kconfig
config KERNEL_HACK
	tristate "Kernel Hack Driver"
	default m
	depends on MODULES
	help
	This is the kernel hack driver for android system.
```
